# Keil uVision project example.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MK20DN128xxx5 NXP
  pack: Keil.Kinetis_K20_DFP.1.3.0
  cpu: IRAM(0x20000000,0x2000) IRAM2(0x1FFFE000,0x2000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: example
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
